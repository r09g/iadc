v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 1040 -1210 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 1040 -1190 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 1060 -1130 0 0 {name=p3 lab=data_in}
C {devices/ipin.sym} 1060 -1110 0 0 {name=p4 lab=clk
}
C {devices/ipin.sym} 1060 -1090 0 0 {name=p5 lab=rst_n
}
C {devices/ipin.sym} 1060 -1070 0 0 {name=p6 lab=sclk
}
C {devices/ipin.sym} 1060 -1050 0 0 {name=p7 lab=cs_n
}
C {devices/opin.sym} 1050 -1030 0 0 {name=p8 lab=new_data}
C {devices/opin.sym} 1050 -1010 0 0 {name=p9 lab=serial_data_out}
C {devices/opin.sym} 1050 -990 0 0 {name=p10 lab=data_out[11:0]}
C {devices/iopin.sym} 1040 -1170 0 0 {name=p11 lab=VSUBS}
